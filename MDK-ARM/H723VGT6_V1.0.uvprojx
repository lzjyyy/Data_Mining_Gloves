# Keil uVision project H723VGT6_V1.0.uvprojx, settings and files
target H723VGT6_V1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H723VGT6_V1.0 +hex
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__CC_ARM,__TARGET_FPU_VFP,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../UserCode/Bsp;../UserCode/Lib;../UserCode/Tasks;../UserCode/Model;../Drivers/CMSIS/DSP/Include
  asm include: ../Core/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group UserCode/Tasks
    ../UserCode/Tasks/: PosLoopTask.c PosLoopTask.h SpdLoopTask.c SpdLoopTask.h CurrLoopTask.c CurrLoopTask.h EncSenseTask.c EncSenseTask.h CurrSenseTask.c CurrSenseTask.h TempSenseTask.c TempSenseTask.h StoreTask.c StoreTask.h Rs485RecvTask.c Rs485RecvTask.h UartDbgTask.c UartDbgTask.h LaunchTask.c LaunchTask.h SysCtrlTask.c SysCtrlTask.h TestTask.c TestTask.h KinSolverTask.c KinSolverTask.h LedTask.c CANFDRecvTask.c
  group UserCode/Lib
    ../UserCode/Lib/: uart_redirect.c uart_redirect.h filter.c filter.h data_manager.c data_manager.h base_convert.c base_convert.h crc.c crc.h pid.c pid.h TrapTrajPlanner.c TrapTrajPlanner.h Action.c Action.h Kin_Slover.c Kin_Slover.h sysConfig.h rs485_handlers.c rs485_protocol.c angle_Mapping.c eso.c eso.h fw_version.c canfd_handlers.c canfd_protocol.c
  group UserCode/Bsp
    ../UserCode/Bsp/: BspUart.c BspUart.h motor_bsp.c motor_bsp.h AT24C256.c AT24C256.h Keys.c Keys.h
    ../Core/Src/: ws2816a_spi_test.c
  group User/Model
    ../UserCode/Model/: Kmodel.c Kmodel_data.c
  group Application/User/Core
    ../Core/Src/: bsp_fdcan.c main.c gpio.c freertos.c adc.c dma.c fdcan.c i2c.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.4.0
